# Keil uVision project STM32F1.uvprojx, settings and files
target STM32F1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F1 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: .\system;.\user\inc;.\user\iic;.\user\aht10;.\user\sht30
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group system
    ./system/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
    ./user/src/: stm32f10x_flash.c
  group user
    ./user/src/: main.c led.c delay.c usart.c
